# Keil uVision project finalproject.uvprojx, settings and files
target final (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC1114FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: finalproject
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\src;..\out
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group UserCode
    ./: main.c
  group DriverCode
    ./: ADC.c INIT.c Display.c
    ../src/: UART.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
